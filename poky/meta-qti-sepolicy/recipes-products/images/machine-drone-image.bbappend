include selinux-image-common.inc
