FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://fix-setools-compilation-errors.patch"
