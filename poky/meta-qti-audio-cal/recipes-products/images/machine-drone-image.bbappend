# Audio non-open source packages to be put to the image filesystem.
include ${BASEMACHINE}/${BASEMACHINE}-drone-qti-image.inc
