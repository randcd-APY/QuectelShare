# BT proprietary Packages
include ${BASEMACHINE}/${BASEMACHINE}-robot-bt-image.inc
