# BT proprietary Packages
include ${BASEMACHINE}/${BASEMACHINE}-bt-image.inc
