# Wfd proprietary packages
include ${BASEMACHINE}/${BASEMACHINE}-wfd-concam-image.inc
