# Wfd proprietary packages
include ${BASEMACHINE}/${BASEMACHINE}-wfd-drone-image.inc
