# Wfd proprietary packages
include ${BASEMACHINE}/${BASEMACHINE}-wfd-image.inc
