# Additional proprietary packages to be put to the image filesystem.
include ${BASEMACHINE}/${BASEMACHINE}-robot-image.inc
