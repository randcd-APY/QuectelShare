# Data proprietary PACKAGES
include msm8909-image.inc