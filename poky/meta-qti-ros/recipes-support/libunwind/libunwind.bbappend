EXTRA_OECONF_append = "--disable-minidebuginfo"
