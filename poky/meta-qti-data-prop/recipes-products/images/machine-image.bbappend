# Data proprietary PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-data-image.inc