# gfx proprietary SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-gfx-minimal-image.inc
