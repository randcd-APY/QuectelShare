# gfx proprietary SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-robot-gfx-image.inc
