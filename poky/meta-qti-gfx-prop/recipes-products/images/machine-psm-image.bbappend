# gfx proprietary SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-gfx-image.inc