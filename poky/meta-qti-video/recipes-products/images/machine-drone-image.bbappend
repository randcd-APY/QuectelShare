# VIDEO PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-video-image.inc
