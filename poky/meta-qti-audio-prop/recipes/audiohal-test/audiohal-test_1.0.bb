inherit qcommon qlicense

DESCRIPTION = "audiohal test app"
PR = "r0"

SRC_DIR = "${WORKSPACE}/audio/mm-audio-apps/audiohal_test/"

S = "${WORKDIR}/audio/mm-audio-apps/audiohal_test/"

DEPENDS = "audiohal"
