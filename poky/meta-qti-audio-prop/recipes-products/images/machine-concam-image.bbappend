# Audio non-open source packages to be put to the image filesystem.
include ${BASEMACHINE}/${BASEMACHINE}-concam-qti-image.inc
