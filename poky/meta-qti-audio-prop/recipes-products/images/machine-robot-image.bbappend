# Audio non-open source packages to be put to the image filesystem.
include ${BASEMACHINE}/${BASEMACHINE}-robot-qti-image.inc
