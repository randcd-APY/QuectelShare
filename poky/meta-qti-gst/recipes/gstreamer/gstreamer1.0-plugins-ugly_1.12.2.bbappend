LICENSE_FLAGS_WHITELIST = "commercial"

