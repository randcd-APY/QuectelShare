FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://misc_create_inode.c-label_rootfs.patch"
