FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

inherit enable-selinux
