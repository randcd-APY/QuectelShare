# wlan proprietary Packages
include ${BASEMACHINE}/${BASEMACHINE}-drone-wlan-image.inc

#IMAGE_INSTALL_append_apq8096 += "qcacld-utils wlan-services"
