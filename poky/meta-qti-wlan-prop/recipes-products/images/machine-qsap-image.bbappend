# wlan proprietary Packages
include ${BASEMACHINE}/${BASEMACHINE}-qsap-wlan-image.inc
