# wlan proprietary Packages
include ${BASEMACHINE}/${BASEMACHINE}-wlan-image.inc