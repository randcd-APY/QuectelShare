# wlan proprietary Packages
include ${BASEMACHINE}/${BASEMACHINE}-robot-wlan-image.inc
