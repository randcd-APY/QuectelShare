# display PROP PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-display-prop-image.inc
