require python-catkin-pkg.inc

inherit distutils
