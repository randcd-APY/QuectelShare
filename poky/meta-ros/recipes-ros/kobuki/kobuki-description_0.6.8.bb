SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=34a63a1385d48407a2e473010f146ea7"

DEPENDS = "xacro urdf"

inherit catkin
require kobuki.inc


