SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=6c7fc5cfcf8095ad495a984923b08bd5"

DEPENDS = "catkin kobuki-msgs nodelet pluginlib roscpp sensor-msgs"

inherit catkin
require kobuki.inc


