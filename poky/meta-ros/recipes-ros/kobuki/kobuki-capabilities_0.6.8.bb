SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=2c744dffd279d7e9e0910ce594eb4f4f"

DEPENDS = "catkin kobuki-node nodelet"

inherit catkin
require kobuki.inc


