SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=4cbf429eb5ad3792202780bf0f50fc90"

DEPENDS = "catkin ecl-build ecl-license"

inherit catkin
require ecl-lite.inc


