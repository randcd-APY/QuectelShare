SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=3aaf85addbebd6d91229a981c49afb8b"

DEPENDS = "catkin ecl-config ecl-license"

inherit catkin
require ecl-lite.inc


