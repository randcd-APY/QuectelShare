SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=10;md5=d41d8cd98f00b204e9800998ecf8427e"


DEPENDS = "ecl-mobile-robot"

require kobuki-core.inc

