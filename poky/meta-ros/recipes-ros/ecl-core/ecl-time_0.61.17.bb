SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=dea2a60709005c1252ec6e29705781fa"

DEPENDS = "catkin ecl-build ecl-config ecl-errors ecl-exceptions ecl-license ecl-time-lite"

inherit catkin
require ecl-core.inc


