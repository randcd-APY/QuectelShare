SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=68b329da9893e34099c7d8ad5cb9c940"

DEPENDS = "catkin ecl-config ecl-errors ecl-license ecl-concepts ecl-exceptions ecl-mpl ecl-converters ecl-errors ecl-formatters ecl-type-traits ecl-utilities"

inherit catkin
require ecl-core.inc


