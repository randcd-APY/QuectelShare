SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=7e5d16d8c437ced2a633e1835daa949d"

DEPENDS = "catkin ecl-build ecl-config ecl-errors ecl-exceptions ecl-license ecl-time ecl-time-lite"

inherit catkin
require ecl-core.inc


