SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d25939bd242aba3a145910b448c43b6d"

DEPENDS = "catkin ecl-config ecl-errors ecl-license ecl-concepts ecl-exceptions ecl-mpl ecl-converters ecl-devices"

inherit catkin
require ecl-core.inc


