SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "catkin ecl-config ecl-errors ecl-license ecl-mpl ecl-type-traits  ecl-containers ecl-utilities ecl-threads"

inherit catkin
require ecl-core.inc


