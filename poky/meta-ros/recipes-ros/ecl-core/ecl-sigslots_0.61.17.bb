SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=413efa5e5e93bd5e8d4fb99b17e3d944"

DEPENDS = "catkin ecl-config ecl-errors ecl-license ecl-concepts ecl-exceptions ecl-mpl ecl-threads"

inherit catkin
require ecl-core.inc


