SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=5ac099ba7dcb3bca119d375c3fbb8124"

DEPENDS = "catkin ecl-build ecl-concepts ecl-config ecl-errors ecl-exceptions ecl-license ecl-time ecl-utilities"

inherit catkin
require ecl-core.inc


