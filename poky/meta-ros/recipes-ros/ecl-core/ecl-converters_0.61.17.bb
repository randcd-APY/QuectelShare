SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=3d2a1d259f128201c1185efc7b92c7b3"

DEPENDS = "catkin ecl-config ecl-errors ecl-license ecl-concepts ecl-exceptions ecl-mpl"

inherit catkin
require ecl-core.inc


