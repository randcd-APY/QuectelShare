SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=76a6cb36a88f0bd16d0304a7e8a97bb2"

DEPENDS = "catkin ecl-mobile-robot"

inherit catkin
require ecl-navigation.inc


