include ${BASEMACHINE}/${BASEMACHINE}-recovery-image.inc
