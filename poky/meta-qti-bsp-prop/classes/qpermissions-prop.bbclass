require conf/distro/qpermissions-prop.conf

inherit qpermissions
