# Audio proprietary packages to be put to the image filesystem.
include ${BASEMACHINE}/${BASEMACHINE}-qti-minimal-image.inc
