# Core proprietary PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-core-image.inc