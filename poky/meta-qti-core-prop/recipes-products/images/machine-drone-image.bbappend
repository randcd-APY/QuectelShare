# Core proprietary PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-drone-core-image.inc