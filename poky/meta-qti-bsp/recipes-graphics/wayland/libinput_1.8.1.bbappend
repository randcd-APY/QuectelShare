
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-evdev-skip-input-devices-that-are-pure-accelerometer.patch"
