# location proprietary packages
include ${BASEMACHINE}/${BASEMACHINE}-location-image.inc
