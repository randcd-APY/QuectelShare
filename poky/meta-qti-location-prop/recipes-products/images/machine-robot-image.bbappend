# location proprietary packages
include ${BASEMACHINE}/${BASEMACHINE}-robot-location-image.inc
