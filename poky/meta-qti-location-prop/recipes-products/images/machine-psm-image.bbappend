# Location non-open source packages to be put to the image filesystem.
include ${BASEMACHINE}/${BASEMACHINE}-psm-location-image.inc
