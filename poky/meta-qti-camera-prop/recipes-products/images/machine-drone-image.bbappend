# Camera proprietary packages
include ${BASEMACHINE}/${BASEMACHINE}-camera-drone-image.inc
