# Camera proprietary packages
include ${BASEMACHINE}/${BASEMACHINE}-camera-robot-image.inc
