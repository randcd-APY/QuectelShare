# Camera proprietary packages
include ${BASEMACHINE}/${BASEMACHINE}-camera-concam-image.inc
