# Camera proprietary packages
include ${BASEMACHINE}/${BASEMACHINE}-camera-minimal-image.inc
