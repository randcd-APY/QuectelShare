FILESEXTRAPATHS_prepend := "${THISDIR}/wpa-supplicant:"
SRC_URI += "\
	file://0100-Add-other-WPS-actions.patch;striplevel=2 \
	"
