inherit qcommon qprebuilt qlicense

DESCRIPTION = "Quectel Alpha system"
PR = "r7"

#DEPENDS = "ql-spi"

SRC_DIR = "${WORKSPACE}/quectel-app/peripheral/spi/"

S = "${WORKDIR}/quectel-app/peripheral/spi"

ProjectName = "${QUECTEL_PROJECT_NAME}"
ProjectRev =  "${QUECTEL_PROJECT_REV}"

